Commit message: Use PPO in the Terrain Curriculum

File: giadog/mini_ros/urdf/spot.urdf (robot description, URDF)
Before this commit: robot spot, 25 links, 24 joints
Links:
- link base_link: mass 0 -> 1
